COMPATIBLE_MACHINE:aptiv_cvc_sousa = "aptiv_cvc_sousa"
